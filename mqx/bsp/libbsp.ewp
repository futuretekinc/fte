# IAR project libbsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../source/tad; ../source/psp/cortex_m/cpu; ../source/psp/cortex_m/core/M4; ../source/psp/cortex_m/compiler/iar; ../source/psp/cortex_m; ../source/io/usb; ../source/io/timer; ../source/io/tfs; ../source/io/tchres; ../source/io/spi; ../source/io/serial; ../source/io/sdcard/sdcard_spi; ../source/io/sdcard/sdcard_esdhc; ../source/io/sdcard; ../source/io/rtc; ../source/io/pipe; ../source/io/pcflash; ../source/io/pccard; ../source/io/pcb/mqxa; ../source/io/pcb; ../source/io/lwgpio; ../source/io/lpm; ../source/io/io_null; ../source/io/io_mem; ../source/io/io_dun; ../source/io/i2s/int; ../source/io/i2s; ../source/io/i2c/polled; ../source/io/i2c/int; ../source/io/i2c; ../source/io/hwtimer; ../source/io/hmi/TSS/shared; ../source/io/hmi; ../source/io/gpio/kgpio; ../source/io/gpio; ../source/io/flashx/freescale; ../source/io/flashx; ../source/io/esdhc; ../source/io/enet/phy; ../source/io/enet/macnet; ../source/io/enet; ../source/io/dma; ../source/io/debug; ../source/io/cm; ../source/io/can/flexcan; ../source/io/adc/kadc; ../source/io/adc; ../source/include; ../source/bsp; ../../config; ../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../source/tad; ../source/psp/cortex_m/cpu; ../source/psp/cortex_m/core/M4; ../source/psp/cortex_m/compiler/iar; ../source/psp/cortex_m; ../source/io/usb; ../source/io/timer; ../source/io/tfs; ../source/io/tchres; ../source/io/spi; ../source/io/serial; ../source/io/sdcard/sdcard_spi; ../source/io/sdcard/sdcard_esdhc; ../source/io/sdcard; ../source/io/rtc; ../source/io/pipe; ../source/io/pcflash; ../source/io/pccard; ../source/io/pcb/mqxa; ../source/io/pcb; ../source/io/lwgpio; ../source/io/lpm; ../source/io/io_null; ../source/io/io_mem; ../source/io/io_dun; ../source/io/i2s/int; ../source/io/i2s; ../source/io/i2c/polled; ../source/io/i2c/int; ../source/io/i2c; ../source/io/hwtimer; ../source/io/hmi/TSS/shared; ../source/io/hmi; ../source/io/gpio/kgpio; ../source/io/gpio; ../source/io/flashx/freescale; ../source/io/flashx; ../source/io/esdhc; ../source/io/enet/phy; ../source/io/enet/macnet; ../source/io/enet; ../source/io/dma; ../source/io/debug; ../source/io/cm; ../source/io/can/flexcan; ../source/io/adc/kadc; ../source/io/adc; ../source/include; ../config; ../config/common
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ../source/tad; ../source/psp/cortex_m/cpu; ../source/psp/cortex_m/core/M4; ../source/psp/cortex_m/compiler/iar; ../source/psp/cortex_m; ../source/io/usb; ../source/io/timer; ../source/io/tfs; ../source/io/tchres; ../source/io/spi; ../source/io/serial; ../source/io/sdcard/sdcard_spi; ../source/io/sdcard/sdcard_esdhc; ../source/io/sdcard; ../source/io/rtc; ../source/io/pipe; ../source/io/pcflash; ../source/io/pccard; ../source/io/pcb/mqxa; ../source/io/pcb; ../source/io/lwgpio; ../source/io/lpm; ../source/io/io_null; ../source/io/io_mem; ../source/io/io_dun; ../source/io/i2s/int; ../source/io/i2s; ../source/io/i2c/polled; ../source/io/i2c/int; ../source/io/i2c; ../source/io/hwtimer; ../source/io/hmi/TSS/shared; ../source/io/hmi; ../source/io/gpio/kgpio; ../source/io/gpio; ../source/io/flashx/freescale; ../source/io/flashx; ../source/io/esdhc; ../source/io/enet/phy; ../source/io/enet/macnet; ../source/io/enet; ../source/io/dma; ../source/io/debug; ../source/io/cm; ../source/io/can/flexcan; ../source/io/adc/kadc; ../source/io/adc; ../source/include; ../source/; ../../config; ../../config/common
  ILINK.IlinkOutputFile: libgeneric.out
  group BSP Files
    ../source/bsp/: bsp.h bsp_cm.c bsp_cm.h bsp_prv.h bsp_rev.h fts_base.h init_adc.c init_bsp.c init_cfcard.c init_enet.c init_esdhc.c init_flashx.c init_gpio.c init_hmi.c init_hw.c init_i2c.c init_i2s.c init_iodebug.c init_lpm.c init_lpm.h init_sci.c init_sdcard.c init_spi.c init_tchres.c init_usb.c mqx_init.c mqx_main.c PE_LDD.h TSS_SystemSetup.h vectors.c
    ../source/io/enet/: enet.h enet_wifi.h ethernet.h
    ../../../../config/common/: maximum_config.h small_ram_config.h smallest_config.h verif_enabled_config.h
    ../source/include/: mqx.h
  group fts_base User Config
    ../../config/: user_config.h
  group Generic IO Drivers/cm
    ../source/io/cm/: cm.c cm.h cm_kinetis.h
  group Generic IO Drivers/debug
    ../source/io/debug/: iodebug.c iodebug.h iodebug_asm.S iodebug_prv.h
  group Generic IO Drivers/hmi
    ../source/io/hmi/: btnled.c btnled.h derivative.h hmi_client.c hmi_client.h hmi_lwgpio_provider.c hmi_lwgpio_provider.h hmi_provider.h hmi_tss_provider.c hmi_tss_provider.h hmi_uids.h
  group Generic IO Drivers/hmi/tss
    ../source/io/hmi/TSS/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
  group Generic IO Drivers/io_dun
    ../source/io/io_dun/: io_dun.c io_dun.h
  group Generic IO Drivers/io_mem
    ../source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/iopipe
    ../source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Generic IO Drivers/lpm
    ../source/io/lpm/: lpm.c lpm.h lpm_kinetis.h lpm_mc.c lpm_prv.h
  group Generic IO Drivers/pcb
    ../source/io/pcb/: io_pcb.c io_pcb.h io_pcb2.c iop_inst.c iopcbprv.h
    ../source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
  group Generic IO Drivers/tfs
    ../source/io/tfs/: tfs.c tfs.h tfs_prv.h
  group Peripheral IO Drivers/adc
    ../source/io/adc/: adc.c adc.h adc_conf.h adc_prv.h
    ../source/io/adc/kadc/: adc_mk60.c adc_mk60.h
  group Peripheral IO Drivers/adc/kadc
    ../source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adt_kpdb.c
  group Peripheral IO Drivers/dma
    ../source/io/dma/: dma.c dma.h edma.c edma.h edma_kinetis.c
  group Peripheral IO Drivers/enet
    ../source/io/enet/: enaddr.c enclose.c enerr.c enet_rev.h enetprv.h eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c
    ../source/io/enet/macnet/: macnet_mk60.c macnet_mk60.h
  group Peripheral IO Drivers/enet/macnet
    ../source/io/enet/macnet/: macnet_1588.c macnet_1588.h macnet_init.c macnet_join.c macnet_mii.c macnet_prv.h macnet_receive.c macnet_rejoin.c macnet_rev.h macnet_send.c macnet_stop.c macnet_util.c
  group Peripheral IO Drivers/enet/phy
    ../source/io/enet/phy/: phy.h phy_fte.c phy_fte.h phy_ksz8041.c phy_ksz8041.h phy_mv88e6060.c phy_mv88e6060.h phy_rtl8201.c phy_rtl8201.h
  group Peripheral IO Drivers/esdhc
    ../source/io/esdhc/: esdhc.c esdhc.h esdhc_mk60.c esdhc_prv.h
  group Peripheral IO Drivers/flashx
    ../source/io/flashx/freescale/: flash_mk60.c flash_mk60.h
    ../source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../source/io/flashx/freescale/: flash_ftfl.c flash_ftfl.h flash_ftfl_prv.h
  group Peripheral IO Drivers/flexcan
    ../source/io/can/flexcan/: flexcan_mk60.c kflexcan.c kflexcan.h kflexcan_int.c
  group Peripheral IO Drivers/gpio
    ../source/io/gpio/: io_gpio.c io_gpio.h io_gpio_prv.h
  group Peripheral IO Drivers/gpio/knxx
    ../source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers/hwtimer
    ../source/io/hwtimer/: hwtimer.c hwtimer.h hwtimer_kinetis.c hwtimer_pit.c hwtimer_pit.h hwtimer_systick.c hwtimer_systick.h
  group Peripheral IO Drivers/i2c
    ../source/io/i2c/: i2c.h i2c_ki2c.h i2c_ki2c_prv.h i2c_mk60.c
    ../source/io/i2c/int/: i2c_int_ki2c.c
    ../source/io/i2c/polled/: i2c_pol_ki2c.c
  group Peripheral IO Drivers/i2c/int
    ../source/io/i2c/int/: i2c_int.c i2c_int_prv.h
  group Peripheral IO Drivers/i2c/polled
    ../source/io/i2c/polled/: i2c_pol.c i2c_pol_prv.h
  group Peripheral IO Drivers/i2s
    ../source/io/i2s/: i2s.h i2s_audio.h i2s_ki2s.h i2s_ki2s_prv.h i2s_mk60.c
    ../source/io/i2s/int/: i2s_int.c i2s_int_prv.h
  group Peripheral IO Drivers/i2s/int
    ../source/io/i2s/int/: i2s_int_ki2s.c
  group Peripheral IO Drivers/lwgpio
    ../source/io/lwgpio/: lwgpio.c lwgpio.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/pccard
    ../source/io/pccard/: apccard.h pccardflexbus.c pccardflexbus.h pccardflexbuspr.h
  group Peripheral IO Drivers/pcflash
    ../source/io/pcflash/: apcflash.c apcflshpr.h ata.h pcflash.h
  group Peripheral IO Drivers/rtc
    ../source/io/rtc/: krtc.c krtc.h rtc.h
  group Peripheral IO Drivers/sdcard
    ../source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers/sdcard/sdcard_esdhc
    ../source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c sdcard_esdhc.h
  group Peripheral IO Drivers/sdcard/sdcard_spi
    ../source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group Peripheral IO Drivers/serial
    ../source/io/serial/: io_sinit.c serial.h serinprv.h serl_kuart.h serl_mk60.c serplprv.h
  group Peripheral IO Drivers/serial/int
    ../source/io/serial/int/: serl_int.c serl_int_kuart.c
  group Peripheral IO Drivers/serial/polled
    ../source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
  group Peripheral IO Drivers/spi
    ../source/io/spi/: spi.c spi.h spi_dspi.c spi_dspi.h spi_dspi_common.c spi_dspi_common.h spi_dspi_dma.c spi_dspi_dma.h spi_dspi_dma_prv.h spi_dspi_prv.h spi_mk60.c spi_prv.h
  group Peripheral IO Drivers/tchres
    ../source/io/tchres/: tchres.c tchres.h tchres_prv.h
  group Peripheral IO Drivers/timer
    ../source/io/timer/: qpit.h timer_kinetis.c timer_lpt.c timer_lpt.h timer_lpt_kinetis.c timer_qpit.c timer_qpit.h
  group Peripheral IO Drivers/usb
    ../source/io/usb/: if_dev_ehci.h if_dev_khci.h if_host_ehci.h if_host_khci.h usb_bsp.h usb_install.c usb_mk60.c usb_mk60_device.c
