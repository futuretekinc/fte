<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader\bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cyassl-3.3.0\IDE\IAR-EWARM\Projects\CyaSSL-Lib\CyaSSL-Lib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\target\future_edgenode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\jsmn\jsmn.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mqx\bsp\libbsp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mqtt\libemqtt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mfs\libmfs.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\nxjson\libnxjson.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mqx\psp\libpsp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rtcs\librtcs.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\shell\libshell.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb\device\libusbd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb\host\libusbh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\nanostack\nanostack.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>fts_s1</project>
        <configuration>Int Flash Release</configuration>
      </member>
      <member>
        <project>libbsp</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libbsp</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libemqtt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libemqtt</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libmfs</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libmfs</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libpsp</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libpsp</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>librtcs</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>librtcs</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libshell</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libshell</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libusbd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusbd</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libusbh</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusbh</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>fts_s1</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>libbsp</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libbsp</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libemqtt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libemqtt</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libmfs</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libmfs</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libpsp</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libpsp</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>librtcs</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>librtcs</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libshell</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libshell</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libusbd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusbd</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libusbh</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusbh</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>libbsp</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libbsp</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libemqtt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libemqtt</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libmfs</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libmfs</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libpsp</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libpsp</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>librtcs</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>librtcs</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libshell</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libshell</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libusbd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusbd</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libusbh</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusbh</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug - libraries only</name>
      <member>
        <project>libbsp</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libemqtt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libmfs</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libpsp</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>librtcs</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libshell</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusbd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusbh</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release - Libraries only</name>
      <member>
        <project>libbsp</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libemqtt</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libmfs</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libpsp</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>librtcs</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libshell</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libusbd</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libusbh</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


