# IAR project nanostack.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCIncludePath2: include; ../mqx/source/include; ../config; ../config/common; ../include/shell; ../include/rtcs; ../mqx/include/psp; ../mqx/include/psp/cortex_m; ../mqx/include/bsp/Sources; ../mqx/include/bsp/Generated_Code; ../mqx/include/bsp; ../mqx/include; ../rtcs/source/include; ../target/include; ../target/include/sys
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: nanostack.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: mac_15_4.c
