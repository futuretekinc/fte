# IAR project libmodbus.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: modbus\include; demo\MK60D\port; modbus\rtu; modbus\tcp; modbus\ascii
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libmodbus.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Include
    modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group Port
    demo/MK60D/port/: port.h portevent.c portother.c portserial.c porttimer.c
  group Source
    modbus/: mb.c
  group Source/ascii
    modbus/ascii/: mbascii.c
  group Source/functions
    modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Source/rtu
    modbus/rtu/: mbcrc.c mbrtu.c
  group Source/tcp
    modbus/tcp/: mbtcp.c
