# IAR project future_edgenode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: FTE_EH3=1; FTE_V2=1; FTE_DEBUG=1; FREESCALE_MQX; NO_FILESYSTEM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../config; source/net/802_15_4/include; include; include/net; include/protocol; include/target; include/dev; include/drv; include/task; include/obj; include/sys; include/lora; ../mqx/include; ../mqx/include/bsp; ../mqx/include/bsp/Sources; ../mqx/include/bsp/Generated_Code; ../mqx/include/common; ../mqx/include/psp; ../mqx/include/psp/cortex_m; ../rtcs/source/include; ../rtcs/source/httpd; ../shell/source/include; ../mqtt/include; ../cyassl-3.3.0; ../mfs/source/include; ../mqx/source/io/enet/phy; ../jsmn; ../nxjson; ../bootloader/src/application; ../FNET 1.0.0/fnet_stack; ../bootloader/src; ../FNET 1.0.0/fnet_stack/compiler; ../FNET 1.0.0/fnet_stack/cpu; ../FNET 1.0.0/fnet_stack/cpu/mk; ../FNET 1.0.0/fnet_stack/os; ../FNET 1.0.0/fnet_stack/services; ../FNET 1.0.0/fnet_stack/services/dhcp; ../FNET 1.0.0/fnet_stack/services/flash; ../FNET 1.0.0/fnet_stack/services/fs; ../FNET 1.0.0/fnet_stack/services/http; ../FNET 1.0.0/fnet_stack/services/poll; ../FNET 1.0.0/fnet_stack/services/serial; ../FNET 1.0.0/fnet_stack/services/shell; ../FNET 1.0.0/fnet_stack/services/telnet; ../FNET 1.0.0/fnet_stack/services/tftp; ../FNET 1.0.0/fnet_stack/stack; LoRa; LoRa/boards/fte; LoRa/mac; LoRa/radio; LoRa/radio/sx1276; LoRa/system; LoRa/system/crypto; LoRa/boards/mcu/mk60; ../freemodbus-v1.5.0/modbus/include; ../freemodbus-v1.5.0/demo/MK60D/port; ../freemodbus-v1.5.0/modbus/rtu; ../freemodbus-v1.5.0/modbus/tcp; ../freemodbus-v1.5.0/modbus/ascii
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: include; include/net; include/target; ../../mqx/include; ../../mqx/include/bsp; ../../mqx/include/bsp/Sources; ../../mqx/include/bsp/Generated_Code; ../../mqx/include/common; ../../mqx/include/psp; ../../mqx/include/psp/cortex_m; ../../include/rtcs; ../../include/httpd; ../../include/shell
  OBJCOPY.OOCOutputFile: fte.bin
  ILINK.IlinkOutputFile: fts_base.out
  ILINK.IlinkIcfFile: config/fte_bl.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FTE_ES1=1
  ICCARM.CCIncludePath2: include; include/net; include/target; include/dev; include/task; include/obj; ../mqx/include; ../mqx/include/bsp; ../mqx/include/bsp/Sources; ../mqx/include/bsp/Generated_Code; ../mqx/include/common; ../mqx/include/psp; ../mqx/include/psp/cortex_m; ../rtcs/source/include; ../rtcs/source/httpd; ../shell/source/include
  OBJCOPY.OOCOutputFile: future_edgenode.srec
  ILINK.IlinkIcfFile: config\fte.icf
  group config
    config/: fte.icf fte_bl.icf fte_mib.def
  group Include
    include/: fte_buff.h fte_config.h fte_crc.h fte_debug.h fte_list.h fte_log.h fte_md5.h fte_mem.h fte_net.h fte_time.h fte_type.h fte_utils.h fte_value.h
  group Include/dev
    include/dev/: fte_dev.h
  group Include/drv
    include/drv/: fte_1wire.h fte_ad7785.h fte_drv.h fte_gpio.h fte_i2c.h fte_lwgpio.h fte_m25p16.h fte_mcp23s08.h fte_mcp23s08_gpio.h fte_spi.h fte_ssd1305.h fte_ucm.h fte_ucs.h
  group Include/net
    include/net/: fte_cgi.h fte_http.h fte_json.h fte_mqtt.h fte_smng.h fte_snmp.h fte_ssl.h fte_telnetd.h
  group Include/obj
    include/obj/: fte_cozir.h fte_di.h fte_dio_node.h fte_do.h fte_ds18b20.h fte_fis.h fte_ftlm.h fte_gus.h fte_ioex.h fte_led.h fte_rl.h fte_rtd.h fte_sht.h fte_srf.h
    include/: fte_object.h
  group Include/target
    include/target/: fte_common.h fte_eh1.h fte_eh2.h fte_eh3.h fte_ep1.h fte_es.h fte_es1.h fte_es10.h fte_es11.h fte_es12.h fte_es13.h fte_es14.h fte_es15.h fte_es16.h fte_es18.h fte_es19.h fte_es2.h fte_es21.h fte_es22.h fte_es4.h fte_es5.h fte_es7.h fte_es8.h fte_es9.h fte_mn1.h fte_mst.h
    include/: fte_target.h
  group Include/task
    include/task/: fte_task.h fte_task_main.h fte_task_mqttd.h fte_task_netd.h fte_task_object_management.h fte_task_shell.h fte_task_timer.h fte_task_watchdog.h
  group LoRa
    LoRa/: fte_lora.c fte_lora_config.c fte_lorawan.c fte_s2lora.c
  group LoRa/boards
    LoRa/boards/FTE/: board.c board.h pinName-board.h pinName-ioe.h rtc-board.c sx1276-board.c sx1276-board.h timer-board.c
  group LoRa/boards/mcu
    LoRa/boards/mcu/mk60/: utilities.c utilities.h
  group LoRa/mac
    LoRa/mac/: LoRaMac.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacNode.c LoRaMacRaw.c
  group LoRa/radio
    LoRa/radio/: radio.h
  group LoRa/radio/sx1276
    LoRa/radio/sx1276/: sx1276.c sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h
  group LoRa/system
    LoRa/system/: delay.c lora_gpio.h lora_spi.h lora_timer.c lora_timer.h
  group LoRa/system/crypto
    LoRa/system/crypto/: aes.c aes.h cmac.c cmac.h
  group MQX Libraries/Debug
    ../mqx/lib/: libbspd.a libpspd.a
    ../cyassl-3.3.0/lib/: libcyassld.a
    ../lib/: libemqttd.a libjsmnd.a libmbtcpd.a libnxjsond.a librtcsd.a libshelld.a
  group MQX Libraries/Release
    ../mqx/lib/: libbsp.a libpsp.a
    ../lib/: libemqtt.a libjsmn.a libmfs.a libnxjson.a librtcs.a libshell.a
  group Source
    source/: fte_buff.c fte_config.c fte_crc16.c fte_crc32.c fte_crc_ccitt.c fte_debug.c fte_json.c fte_list.c fte_log.c fte_md5.c fte_mem.c fte_time.c fte_timer.c fte_utils.c
  group Source/db
    source/db/: fte_db.c
  group Source/drv
    source/drv/: fte_1wire.c fte_ad7785.c fte_drv.c fte_gpio.c fte_i2c.c fte_lwgpio.c fte_m25p16.c fte_mcp23s08.c fte_mcp23s08_gpio.c fte_spi.c fte_ssd1305.c fte_ucs.c
  group Source/event
    source/obj/: fte_event.c
  group Source/LoRa
    source/lora/: fte_lora.c fte_lora_utils.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group Source/mach
    source/mach/: fte_common.c fte_eh1.c fte_eh2.c fte_ep1.c fte_es1.c
  group Source/net
    source/net/: fte_net.c fte_telnetd.c
  group Source/net/802_15_4
    source/net/802_15_4/: cIPv6.c icmp.c mac_15_4.c protocol_lib.c routing.c stack.c xtype.c
  group Source/net/802_15_4/common
    source/net/802_15_4/common/: module.c socket.c
  group Source/net/802_15_4/platform
    source/net/802_15_4/platform/: mac.c rf.c timer.c
  group Source/net/http
    source/net/http/: fte_cgi.c fte_http.c fte_json.c fte_tfs_data.c
  group Source/net/http/scripts
    web_pages/scripts/: fts.js request.js
  group Source/net/http/styles
    web_pages/css/: fts.css
  group Source/net/mbtcp
    source/net/mbtcp/: fte_mbtcp.c
  group Source/net/mqtt
    source/net/mqtt/: fte_mqtt.c
  group Source/net/smng
    source/net/smng/: fte_smng.c
  group Source/net/snmp
    source/net/snmp/: fte_mib.c fte_snmp.c
  group Source/net/ssl
    source/net/ssl/: fte_ssl.c
  group Source/obj
    source/obj/: fte_botem.c fte_cias.c fte_cozir.c fte_di.c fte_dio_node.c fte_do.c fte_dotech.c fte_ds18b20.c fte_elt.c fte_fis.c fte_ftlm.c fte_gai.c fte_gs_dpc.c fte_gus.c fte_ifce.c fte_ioex.c fte_led.c fte_mst_mex510c.c fte_object.c fte_object_description.c fte_pm1001.c fte_rl.c fte_rtd.c fte_sht.c fte_soha.c fte_srf.c fte_tascon.c fte_trueyes.c
    source/: fte_value.c
  group Source/protocol/modbus
    source/protocol/modbus/: fte_modbus.c fte_modbus_gen.c fte_modbus_registers.c
  group Source/shell
    source/shell/: fte_shell.c
  group Source/sys
    source/sys/: fte_sys.c fte_sys_bl.c fte_sys_msg.c fte_sys_timer.c
  group Source/task
    source/task/: fte_task.c fte_task_main.c fte_task_netd.c fte_task_object_management.c fte_task_shell.c fte_task_timer.c fte_task_watchdog.c
