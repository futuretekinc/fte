# IAR project liblora.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: PLATFORM=4; USE_BAND_915=1
  ICCARM.CCIncludePath2: ../config; ../mqx/include; ../mqx/include/bsp; ../mqx/include/bsp/Sources; ../mqx/include/bsp/Generated_Code; ../mqx/include/common; ../mqx/include/psp; ../mqx/include/psp/cortex_m; platform; platform/fte; radio
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: liblora.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Include/Radio
    radio/: radio.h sx1232-Hal.h sx1232-Misc.h sx1232.h sx1272-Fsk.h sx1272-FskMisc.h sx1272-Hal.h sx1272-LoRa.h sx1272-LoRaMisc.h sx1272.h sx1276-Fsk.h sx1276-FskMisc.h sx1276-Hal.h sx1276-LoRa.h sx1276-LoRaMisc.h sx1276.h
  group Source/Radio
    radio/: radio.c sx1232-Misc.c sx1232.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1272.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276.c
