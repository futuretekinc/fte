# IAR project libshell.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../usb/host/source/rtos/mqx; ../usb/host/source/include; ../usb/host/source/host/khci; ../usb/host/source/classes/printer; ../usb/host/source/classes/phdc; ../usb/host/source/classes/msd/mfs; ../usb/host/source/classes/msd; ../usb/host/source/classes/hub; ../usb/host/source/classes/hid; ../usb/host/source/classes/cdc; ../usb/host/source/classes/audio; ../usb/device/source/include/rtos; ../usb/device/source/include/khci; ../usb/device/source/include; ../usb/device/source/classes/include; ../usb/common/include; source/include; ../rtcs/source/include; ../rtcs/source/httpd; ../mqx/source/tad; ../mqx/source/psp/cortex_m/cpu; ../mqx/source/psp/cortex_m/core/M4; ../mqx/source/psp/cortex_m/compiler/iar; ../mqx/source/psp/cortex_m; ../mqx/source/io/usb; ../mqx/source/io/timer; ../mqx/source/io/tfs; ../mqx/source/io/tchres; ../mqx/source/io/spi; ../mqx/source/io/serial; ../mqx/source/io/sdcard/sdcard_spi; ../mqx/source/io/sdcard/sdcard_esdhc; ../mqx/source/io/sdcard; ../mqx/source/io/rtc; ../mqx/source/io/pipe; ../mqx/source/io/pcflash; ../mqx/source/io/pccard; ../mqx/source/io/pcb/mqxa; ../mqx/source/io/pcb; ../mqx/source/io/lwgpio; ../mqx/source/io/lpm; ../mqx/source/io/io_null; ../mqx/source/io/io_mem; ../mqx/source/io/io_dun; ../mqx/source/io/i2s/int; ../mqx/source/io/i2s; ../mqx/source/io/i2c/polled; ../mqx/source/io/i2c/int; ../mqx/source/io/i2c; ../mqx/source/io/hwtimer; ../mqx/source/io/hmi/TSS/shared; ../mqx/source/io/hmi; ../mqx/source/io/gpio/kgpio; ../mqx/source/io/gpio; ../mqx/source/io/flashx/freescale; ../mqx/source/io/flashx; ../mqx/source/io/esdhc; ../mqx/source/io/enet/phy; ../mqx/source/io/enet/macnet; ../mqx/source/io/enet; ../mqx/source/io/dma; ../mqx/source/io/debug; ../mqx/source/io/cm; ../mqx/source/io/can/flexcan; ../mqx/source/io/adc/kadc; ../mqx/source/io/adc; ../mqx/source/include; ../mqx/source/bsp; ../mfs/source/include; ../config; ../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../usb/host/source/rtos/mqx; ../usb/host/source/include; ../usb/host/source/host/khci; ../usb/host/source/classes/printer; ../usb/host/source/classes/phdc; ../usb/host/source/classes/msd/mfs; ../usb/host/source/classes/msd; ../usb/host/source/classes/hub; ../usb/host/source/classes/hid; ../usb/host/source/classes/cdc; ../usb/host/source/classes/audio; ../usb/device/source/include/rtos; ../usb/device/source/include/khci; ../usb/device/source/include; ../usb/device/source/classes/include; ../usb/common/include; source/include; ../rtcs/source/include; ../rtcs/source/httpd; ../mqx/source/tad; ../mqx/source/psp/cortex_m/cpu; ../mqx/source/psp/cortex_m/core/M4; ../mqx/source/psp/cortex_m/compiler/iar; ../mqx/source/psp/cortex_m; ../mqx/source/io/usb; ../mqx/source/io/timer; ../mqx/source/io/tfs; ../mqx/source/io/tchres; ../mqx/source/io/spi; ../mqx/source/io/serial; ../mqx/source/io/sdcard/sdcard_spi; ../mqx/source/io/sdcard/sdcard_esdhc; ../mqx/source/io/sdcard; ../mqx/source/io/rtc; ../mqx/source/io/pipe; ../mqx/source/io/pcflash; ../mqx/source/io/pccard; ../mqx/source/io/pcb/mqxa; ../mqx/source/io/pcb; ../mqx/source/io/lwgpio; ../mqx/source/io/lpm; ../mqx/source/io/io_null; ../mqx/source/io/io_mem; ../mqx/source/io/io_dun; ../mqx/source/io/i2s/int; ../mqx/source/io/i2s; ../mqx/source/io/i2c/polled; ../mqx/source/io/i2c/int; ../mqx/source/io/i2c; ../mqx/source/io/hwtimer; ../mqx/source/io/hmi/TSS/shared; ../mqx/source/io/hmi; ../mqx/source/io/gpio/kgpio; ../mqx/source/io/gpio; ../mqx/source/io/flashx/freescale; ../mqx/source/io/flashx; ../mqx/source/io/esdhc; ../mqx/source/io/enet/phy; ../mqx/source/io/enet/macnet; ../mqx/source/io/enet; ../mqx/source/io/dma; ../mqx/source/io/debug; ../mqx/source/io/cm; ../mqx/source/io/can/flexcan; ../mqx/source/io/adc/kadc; ../mqx/source/io/adc; ../mqx/source/include; ../mqx/source/bsp/fts_base; ../mfs/source/include; ../config/fts_base; ../config/common
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group Shell Source/mfs
    source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
    source/include/: sh_mfs.h
  group Shell Source/mqx
    source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    source/include/: sh_prv.h shell.h
  group Shell Source/rtcs
    source/rtcs/: sh_arpdisp.c sh_clock.c sh_echod.c sh_eds.c sh_enet.c sh_exec.c sh_ftpc.c sh_ftpd.c sh_gate.c sh_getroute.c sh_ghbn.c sh_ipconfig.c sh_iwconfig.c sh_load.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_tftp.c sh_tftpd.c sh_tnet.c sh_tnetd.c
  group Shell Source/shell
    source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    source/include/: sh_enet.h sh_rtcs.h
