# IAR project libmfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../mqx/source/tad; ../mqx/source/psp/cortex_m/cpu; ../mqx/source/psp/cortex_m/core/M4; ../mqx/source/psp/cortex_m/compiler/iar; ../mqx/source/psp/cortex_m; ../mqx/source/io/usb; ../mqx/source/io/timer; ../mqx/source/io/tfs; ../mqx/source/io/tchres; ../mqx/source/io/spi; ../mqx/source/io/serial; ../mqx/source/io/sdcard/sdcard_spi; ../mqx/source/io/sdcard/sdcard_esdhc; ../mqx/source/io/sdcard; ../mqx/source/io/rtc; ../mqx/source/io/pipe; ../mqx/source/io/pcflash; ../mqx/source/io/pccard; ../mqx/source/io/pcb/mqxa; ../mqx/source/io/pcb; ../mqx/source/io/lwgpio; ../mqx/source/io/lpm; ../mqx/source/io/io_null; ../mqx/source/io/io_mem; ../mqx/source/io/io_dun; ../mqx/source/io/i2s/int; ../mqx/source/io/i2s; ../mqx/source/io/i2c/polled; ../mqx/source/io/i2c/int; ../mqx/source/io/i2c; ../mqx/source/io/hwtimer; ../mqx/source/io/hmi/TSS/shared; ../mqx/source/io/hmi; ../mqx/source/io/gpio/kgpio; ../mqx/source/io/gpio; ../mqx/source/io/flashx/freescale; ../mqx/source/io/flashx; ../mqx/source/io/esdhc; ../mqx/source/io/enet/phy; ../mqx/source/io/enet/macnet; ../mqx/source/io/enet; ../mqx/source/io/dma; ../mqx/source/io/debug; ../mqx/source/io/cm; ../mqx/source/io/can/flexcan; ../mqx/source/io/adc/kadc; ../mqx/source/io/adc; ../mqx/source/include; ../mqx/source/bsp; source/include; ../config; ../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../mqx/source/tad; ../mqx/source/psp/cortex_m/cpu; ../mqx/source/psp/cortex_m/core/M4; ../mqx/source/psp/cortex_m/compiler/iar; ../mqx/source/psp/cortex_m; ../mqx/source/io/usb; ../mqx/source/io/timer; ../mqx/source/io/tfs; ../mqx/source/io/tchres; ../mqx/source/io/spi; ../mqx/source/io/serial; ../mqx/source/io/sdcard/sdcard_spi; ../mqx/source/io/sdcard/sdcard_esdhc; ../mqx/source/io/sdcard; ../mqx/source/io/rtc; ../mqx/source/io/pipe; ../mqx/source/io/pcflash; ../mqx/source/io/pccard; ../mqx/source/io/pcb/mqxa; ../mqx/source/io/pcb; ../mqx/source/io/lwgpio; ../mqx/source/io/lpm; ../mqx/source/io/io_null; ../mqx/source/io/io_mem; ../mqx/source/io/io_dun; ../mqx/source/io/i2s/int; ../mqx/source/io/i2s; ../mqx/source/io/i2c/polled; ../mqx/source/io/i2c/int; ../mqx/source/io/i2c; ../mqx/source/io/hwtimer; ../mqx/source/io/hmi/TSS/shared; ../mqx/source/io/hmi; ../mqx/source/io/gpio/kgpio; ../mqx/source/io/gpio; ../mqx/source/io/flashx/freescale; ../mqx/source/io/flashx; ../mqx/source/io/esdhc; ../mqx/source/io/enet/phy; ../mqx/source/io/enet/macnet; ../mqx/source/io/enet; ../mqx/source/io/dma; ../mqx/source/io/debug; ../mqx/source/io/cm; ../mqx/source/io/can/flexcan; ../mqx/source/io/adc/kadc; ../mqx/source/io/adc; ../mqx/source/include; ../mqx/source/bsp
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ../../../../mqx/source/tad; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_dun; ../../../../mqx/source/io/i2s/int; ../../../../mqx/source/io/i2s; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/hmi/TSS/shared; ../../../../mqx/source/io/hmi; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/dma; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/cm; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/include; ../../../../mqx/source/bsp/fts_base; source/include; ../../../../config/fts_base; ../../../../config/common
  ILINK.IlinkOutputFile: libgeneric.out
  group MFS Include
    source/include/: mfs.h mfs_cnfg.h mfs_prv.h mfs_rev.h part_mgr.h
  group MFS Source
    source/generic/: dir_read.c mfs_attribute.c mfs_cluster.c mfs_create.c mfs_data_sector.c mfs_delete.c mfs_dir_entry.c mfs_directory.c mfs_fat.c mfs_format.c mfs_handle.c mfs_init.c mfs_lfn.c mfs_misc.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_valdev.c mfs_write.c part_mgr.c
