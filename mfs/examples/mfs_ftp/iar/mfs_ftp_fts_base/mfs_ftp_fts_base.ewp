# IAR project mfs_ftp_fts_base.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../mfs/examples/mfs_ftp; ../../../../../lib/fts_base.iar/debug/usb; ../../../../../lib/fts_base.iar/debug/rtcs; ../../../../../lib/fts_base.iar/debug/psp; ../../../../../lib/fts_base.iar/debug/mfs; ../../../../../lib/fts_base.iar/debug/bsp/Sources; ../../../../../lib/fts_base.iar/debug/bsp/Generated_Code; ../../../../../lib/fts_base.iar/debug/bsp; ../../../../../lib/fts_base.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: fts_base.out
  ILINK.IlinkIcfFile: ../../../../../lib/fts_base.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../mfs/examples/mfs_ftp; ../../../../../lib/fts_base.iar/release/usb; ../../../../../lib/fts_base.iar/release/rtcs; ../../../../../lib/fts_base.iar/release/psp; ../../../../../lib/fts_base.iar/release/mfs; ../../../../../lib/fts_base.iar/release/bsp/Sources; ../../../../../lib/fts_base.iar/release/bsp/Generated_Code; ../../../../../lib/fts_base.iar/release/bsp; ../../../../../lib/fts_base.iar/release
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/fts_base.iar/release/bsp/intflash.icf
  group Source
    ../../../../../mfs/examples/mfs_ftp/: USB_File.h demo.h USB_File.c USB_Task.h USB_Task.c demo.c usb_classes.c usb_classes.h
  group MQX Libraries
    ../../../../../lib/fts_base.iar/debug/bsp/: bsp.a
    ../../../../../lib/fts_base.iar/debug/mfs/: mfs.a
    ../../../../../lib/fts_base.iar/debug/rtcs/: rtcs.a
    ../../../../../lib/fts_base.iar/debug/usb/: usbh.a
    ../../../../../lib/fts_base.iar/release/mfs/: mfs.a
    ../../../../../lib/fts_base.iar/release/bsp/: bsp.a
    ../../../../../lib/fts_base.iar/release/usb/: usbh.a
    ../../../../../lib/fts_base.iar/debug/psp/: psp.a
    ../../../../../lib/fts_base.iar/release/psp/: psp.a
    ../../../../../lib/fts_base.iar/release/rtcs/: rtcs.a
