# IAR project librtcs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: source/include; source/httpd; ../mqx/source/tad; ../mqx/source/psp/cortex_m/cpu; ../mqx/source/psp/cortex_m/core/M4; ../mqx/source/psp/cortex_m/compiler/iar; ../mqx/source/psp/cortex_m; ../mqx/source/io/usb; ../mqx/source/io/timer; ../mqx/source/io/tfs; ../mqx/source/io/tchres; ../mqx/source/io/spi; ../mqx/source/io/serial; ../mqx/source/io/sdcard/sdcard_spi; ../mqx/source/io/sdcard/sdcard_esdhc; ../mqx/source/io/sdcard; ../mqx/source/io/rtc; ../mqx/source/io/pipe; ../mqx/source/io/pcflash; ../mqx/source/io/pccard; ../mqx/source/io/pcb/mqxa; ../mqx/source/io/pcb; ../mqx/source/io/lwgpio; ../mqx/source/io/lpm; ../mqx/source/io/io_null; ../mqx/source/io/io_mem; ../mqx/source/io/io_dun; ../mqx/source/io/i2s/int; ../mqx/source/io/i2s; ../mqx/source/io/i2c/polled; ../mqx/source/io/i2c/int; ../mqx/source/io/i2c; ../mqx/source/io/hwtimer; ../mqx/source/io/hmi/TSS/shared; ../mqx/source/io/hmi; ../mqx/source/io/gpio/kgpio; ../mqx/source/io/gpio; ../mqx/source/io/flashx/freescale; ../mqx/source/io/flashx; ../mqx/source/io/esdhc; ../mqx/source/io/enet/phy; ../mqx/source/io/enet/macnet; ../mqx/source/io/enet; ../mqx/source/io/dma; ../mqx/source/io/debug; ../mqx/source/io/cm; ../mqx/source/io/can/flexcan; ../mqx/source/io/adc/kadc; ../mqx/source/io/adc; ../mqx/source/include; ../mqx/source/bsp; ../mfs/source/include; ../config; ../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: source/include; source/httpd; ../mqx/source/tad; ../mqx/source/psp/cortex_m/cpu; ../mqx/source/psp/cortex_m/core/M4; ../mqx/source/psp/cortex_m/compiler/iar; ../mqx/source/psp/cortex_m; ../mqx/source/io/usb; ../mqx/source/io/timer; ../mqx/source/io/tfs; ../mqx/source/io/tchres; ../mqx/source/io/spi; ../mqx/source/io/serial; ../mqx/source/io/sdcard/sdcard_spi; ../mqx/source/io/sdcard/sdcard_esdhc; ../mqx/source/io/sdcard; ../mqx/source/io/rtc; ../mqx/source/io/pipe; ../mqx/source/io/pcflash; ../mqx/source/io/pccard; ../mqx/source/io/pcb/mqxa; ../mqx/source/io/pcb; ../mqx/source/io/lwgpio; ../mqx/source/io/lpm; ../mqx/source/io/io_null; ../mqx/source/io/io_mem; ../mqx/source/io/io_dun; ../mqx/source/io/i2s/int; ../mqx/source/io/i2s; ../mqx/source/io/i2c/polled; ../mqx/source/io/i2c/int; ../mqx/source/io/i2c; ../mqx/source/io/hwtimer; ../mqx/source/io/hmi/TSS/shared; ../mqx/source/io/hmi; ../mqx/source/io/gpio/kgpio; ../mqx/source/io/gpio; ../mqx/source/io/flashx/freescale; ../mqx/source/io/flashx; ../mqx/source/io/esdhc; ../mqx/source/io/enet/phy; ../mqx/source/io/enet/macnet; ../mqx/source/io/enet; ../mqx/source/io/dma; ../mqx/source/io/debug; ../mqx/source/io/cm; ../mqx/source/io/can/flexcan; ../mqx/source/io/adc/kadc; ../mqx/source/io/adc; ../mqx/source/include; ../mqx/source/bsp/fts_base; ../mfs/source/include; ../config/fts_base; ../config/common
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: libgeneric.out
  group RTCS Include
    source/include/: addrinfo.h arp.h arp_prv.h arpif.h asn1.h bootp.h ccp.h chap.h checksum.h dhcp.h dhcp_prv.h dhcpsrv.h dhcpuprv.h dns.h fcs16.h ftp.h ftpc.h ftpd.h ftpd_msg.h httpsrv.h httpsrv_prv.h httpsrv_supp.h icmp.h icmp6.h icmp6_prv.h icmp_prv.h igmp.h ip-e.h ip.h ip6.h ip6_if.h ip6_prv.h ip6_trace.h ip_prv.h ipc_udp.h ipc_udp_prv.h ipcfg.h ipcfg_prv.h ipcp.h ipradix.h iptunnel.h iwcfg.h lcp.h md5.h nat.h nat_prv.h nat_session.h natvers.h nd6.h pap.h ppp.h ppp_prv.h pppfsm.h ppphdlc.h rip.h rip_prv.h route.h rtcs.h rtcs25x.h rtcs_base64.h rtcs_in.h rtcs_prv.h rtcs_smtp.h rtcscfg.h rtcshdlc.h rtcslog.h rtcspcb.h rtcsrtos.h rtcstime.h rtcsvers.h snmp.h snmpcfg.h socket.h tcp.h tcp_prv.h tcpip.h telnet.h tftp.h ticker.h udp.h udp_prv.h
  group RTCS Source/apps
    source/apps/: binfile.c coff.c dhcpsrv.c echosrv.c eds.c ftpc.c ftpc_cmd.c ftpclnt.c ftpd.c ftpd_cmd.c ftpd_msg.c httpsrv.c httpsrv_supp.c httpsrv_task.c loadtb.c loadtc.c loadts.c resolver.c rtcs_base64.c rtcs_smtp.c rtcsload.c sntp.c sockio.c srec32.c srecord.c telnet.c telnetio.c telnsrv.c tftp.c tftpacc.c tftpsrv.c tftputil.c
  group RTCS Source/httpd
    source/httpd/: httpd.c httpd.h httpd_cnfg.h httpd_mqx.h httpd_poll.c httpd_prv.h httpd_supp.c httpd_supp.h httpd_task.c httpd_types.h httpd_wrapper.h
  group RTCS Source/if
    source/if/: arpcmd.c dnshosts.c dnsinit.c dnsutil.c getaddrinfo.c getnameinfo.c ghbname.c ifadd.c ifbootp.c ifdhcp.c ifdns.c ifppp.c ifrem.c ifstat.c iftraps.c iftunnel.c inet.c inet_ntop.c inet_pton.c ipcfg.c ipcfg6.c iwcfg.c ping.c ping6.c rtcs.c rtcscmd.c rtcsdela.c rtcsglob.c rtcshost.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sdgram.c sockutil.c soigmp.c soip.c solink.c sosel.c sosock.c sotcp.c soudp.c sstream.c
  group RTCS Source/media
    source/media/: arp.c arpinit.c ip-e.c ip6-e.c ipcp.c ipcpfsm.c proxyarp.c
  group RTCS Source/nat
    source/nat/: alggen.c dnat.c ifdnat.c ifnat.c nat.c nat_apply.c natalg.c natdata.c natevent.c natftp.c nattftp.c sonat.c
  group RTCS Source/os
    source/os/mqx25x/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group RTCS Source/ppp
    source/ppp/: ccp.c chap.c gen16.c genmd5.c lcp.c lcpif.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group RTCS Source/snmp
    source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group RTCS Source/tcpip
    source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c checksum6.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_reasm.c ipif_add.c ipif_rem.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcpip.c ticker.c timer.c udp.c
