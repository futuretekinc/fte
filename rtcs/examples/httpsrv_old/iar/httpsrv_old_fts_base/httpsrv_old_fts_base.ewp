# IAR project httpsrv_old_fts_base.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../rtcs/examples/httpsrv_old; ../../../../../lib/fts_base.iar/debug/shell; ../../../../../lib/fts_base.iar/debug/rtcs; ../../../../../lib/fts_base.iar/debug/psp; ../../../../../lib/fts_base.iar/debug/mfs; ../../../../../lib/fts_base.iar/debug/bsp/Sources; ../../../../../lib/fts_base.iar/debug/bsp/Generated_Code; ../../../../../lib/fts_base.iar/debug/bsp; ../../../../../lib/fts_base.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: fts_base.out
  ILINK.IlinkIcfFile: ../../../../../lib/fts_base.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../rtcs/examples/httpsrv_old; ../../../../../lib/fts_base.iar/release/shell; ../../../../../lib/fts_base.iar/release/rtcs; ../../../../../lib/fts_base.iar/release/psp; ../../../../../lib/fts_base.iar/release/mfs; ../../../../../lib/fts_base.iar/release/bsp/Sources; ../../../../../lib/fts_base.iar/release/bsp/Generated_Code; ../../../../../lib/fts_base.iar/release/bsp; ../../../../../lib/fts_base.iar/release
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/fts_base.iar/release/bsp/intflash.icf
  group Source
    ../../../../../rtcs/examples/httpsrv_old/: tfs_data.c config.h httpdsrv.h cgi.h cgi.c httpdsrv.c
  group MQX Libraries
    ../../../../../lib/fts_base.iar/debug/bsp/: bsp.a
    ../../../../../lib/fts_base.iar/debug/mfs/: mfs.a
    ../../../../../lib/fts_base.iar/debug/rtcs/: rtcs.a
    ../../../../../lib/fts_base.iar/release/shell/: shell.a
    ../../../../../lib/fts_base.iar/debug/shell/: shell.a
    ../../../../../lib/fts_base.iar/release/mfs/: mfs.a
    ../../../../../lib/fts_base.iar/release/bsp/: bsp.a
    ../../../../../lib/fts_base.iar/debug/psp/: psp.a
    ../../../../../lib/fts_base.iar/release/psp/: psp.a
    ../../../../../lib/fts_base.iar/release/rtcs/: rtcs.a
