# IAR project CyaSSL-Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FREESCALE_MQX; CYASSL_IAR_ARM; CYASSL_SMALL_STACK; CYASSL_LOW_MEMORY; IGNORE_NAME_CONSTRAINTS; NO_TIME_H; NO_SKID; HAVE_ANON; HAVE_PK_CALLBACKS; DEBUG_CYASSL
  ICCARM.CCIncludePath2: ../../../../; ../../../../../mqx/include; ../../../../../mqx/include/bsp; ../../../../../mqx/include/common; ../../../../../mqx/include/psp/cortex_m; ../../../../../mqx/include/bsp/Generated_Code; ../../../../../mfs/source/include; ../../../../../rtcs/source/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CyaSSL-Full.srec
  ILINK.IlinkOutputFile: CyaSSL-Lib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FREESCALE_MQX; NO_TIME_H; NO_FILESYSTEM; HAVE_ANON; HAVE_PK_CALLBACKS
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CyaSSL
    ../../../../src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfCrypt
    ../../../../ctaocrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c coding.c compress.c des3.c dh.c dsa.c ecc.c ecc_fp.c error.c hc128.c hmac.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c wc_port.c
