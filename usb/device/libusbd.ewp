# IAR project libusbd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../usb/host/source/host/khci; ../../usb/device/source/include/rtos; ../../usb/device/source/include/khci; ../../usb/device/source/include; ../../usb/device/source/classes/include; ../../usb/common/include; ../../mqx/source/tad; ../../mqx/source/psp/cortex_m/cpu; ../../mqx/source/psp/cortex_m/core/M4; ../../mqx/source/psp/cortex_m/compiler/iar; ../../mqx/source/psp/cortex_m; ../../mqx/source/io/usb; ../../mqx/source/io/timer; ../../mqx/source/io/tfs; ../../mqx/source/io/tchres; ../../mqx/source/io/spi; ../../mqx/source/io/serial; ../../mqx/source/io/sdcard/sdcard_spi; ../../mqx/source/io/sdcard/sdcard_esdhc; ../../mqx/source/io/sdcard; ../../mqx/source/io/rtc; ../../mqx/source/io/pipe; ../../mqx/source/io/pcflash; ../../mqx/source/io/pccard; ../../mqx/source/io/pcb/mqxa; ../../mqx/source/io/pcb; ../../mqx/source/io/lwgpio; ../../mqx/source/io/lpm; ../../mqx/source/io/io_null; ../../mqx/source/io/io_mem; ../../mqx/source/io/io_dun; ../../mqx/source/io/i2s/int; ../../mqx/source/io/i2s; ../../mqx/source/io/i2c/polled; ../../mqx/source/io/i2c/int; ../../mqx/source/io/i2c; ../../mqx/source/io/hwtimer; ../../mqx/source/io/hmi/TSS/shared; ../../mqx/source/io/hmi; ../../mqx/source/io/gpio/kgpio; ../../mqx/source/io/gpio; ../../mqx/source/io/flashx/freescale; ../../mqx/source/io/flashx; ../../mqx/source/io/esdhc; ../../mqx/source/io/enet/phy; ../../mqx/source/io/enet/macnet; ../../mqx/source/io/enet; ../../mqx/source/io/dma; ../../mqx/source/io/debug; ../../mqx/source/io/cm; ../../mqx/source/io/can/flexcan; ../../mqx/source/io/adc/kadc; ../../mqx/source/io/adc; ../../mqx/source/include; ../../mqx/source/bsp; ../../config; ../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ../../usb/host/source/host/khci; ../../usb/device/source/include/rtos; ../../usb/device/source/include/khci; ../../usb/device/source/include; ../../usb/device/source/classes/include; ../../usb/common/include; ../../mqx/source/tad; ../../mqx/source/psp/cortex_m/cpu; ../../mqx/source/psp/cortex_m/core/M4; ../../mqx/source/psp/cortex_m/compiler/iar; ../../mqx/source/psp/cortex_m; ../../mqx/source/io/usb; ../../mqx/source/io/timer; ../../mqx/source/io/tfs; ../../mqx/source/io/tchres; ../../mqx/source/io/spi; ../../mqx/source/io/serial; ../../mqx/source/io/sdcard/sdcard_spi; ../../mqx/source/io/sdcard/sdcard_esdhc; ../../mqx/source/io/sdcard; ../../mqx/source/io/rtc; ../../mqx/source/io/pipe; ../../mqx/source/io/pcflash; ../../mqx/source/io/pccard; ../../mqx/source/io/pcb/mqxa; ../../mqx/source/io/pcb; ../../mqx/source/io/lwgpio; ../../mqx/source/io/lpm; ../../mqx/source/io/io_null; ../../mqx/source/io/io_mem; ../../mqx/source/io/io_dun; ../../mqx/source/io/i2s/int; ../../mqx/source/io/i2s; ../../mqx/source/io/i2c/polled; ../../mqx/source/io/i2c/int; ../../mqx/source/io/i2c; ../../mqx/source/io/hwtimer; ../../mqx/source/io/hmi/TSS/shared; ../../mqx/source/io/hmi; ../../mqx/source/io/gpio/kgpio; ../../mqx/source/io/gpio; ../../mqx/source/io/flashx/freescale; ../../mqx/source/io/flashx; ../../mqx/source/io/esdhc; ../../mqx/source/io/enet/phy; ../../mqx/source/io/enet/macnet; ../../mqx/source/io/enet; ../../mqx/source/io/dma; ../../mqx/source/io/debug; ../../mqx/source/io/cm; ../../mqx/source/io/can/flexcan; ../../mqx/source/io/adc/kadc; ../../mqx/source/io/adc; ../../mqx/source/include; ../../mqx/source/bsp/fts_base; ../../config/fts_base; ../../config/common
  ILINK.IlinkOutputFile: libgeneric.out
  group USB Class Drivers/audio
    source/classes/audio/: usb_audio.c
    source/classes/include/: usb_audio.h
  group USB Class Drivers/cdc
    source/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
    source/classes/include/: usb_cdc.h usb_cdc_pstn.h
  group USB Class Drivers/framework
    source/classes/common/: usb_framework.c
    source/classes/include/: usb_framework.h
  group USB Class Drivers/hid
    source/classes/hid/: usb_hid.c
    source/classes/include/: usb_hid.h
  group USB Class Drivers/msd
    source/classes/msd/: usb_msc.c usb_msc_scsi.c
    source/classes/include/: usb_msc.h usb_msc_scsi.h
  group USB Class Drivers/phdc
    source/classes/phdc/: usb_phdc.c
    source/classes/include/: usb_phdc.h
  group USB Class Drivers/usb_class
    source/classes/common/: usb_class.c
    source/classes/include/: usb_class.h
  group USB Device/include
    source/include/: dev_cnfg.h dev_main.h devapi.h
    ../common/include/: usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_misc_prv.h usb_prv.h usb_types.h
    source/classes/include/: usb_stack_config.h
  group USB Device/os
    source/include/rtos/: mqx_dev.h
  group USB Device/source
    source/device/: dev_cncl.c dev_ep_deinit.c dev_main.c dev_recv.c dev_send.c dev_shut.c dev_utl.c
  group USB Low Level Driver/khci
    source/device/khci/: callback_khci.c khci_dev_main.c
    source/include/khci/: khci_dev_main.h khci_usbprv.h
    ../host/source/host/khci/: khci_prv.h
