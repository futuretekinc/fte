# IAR project libusbh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../usb/host/source/rtos/mqx; ../../usb/host/source/include; ../../usb/host/source/host/khci; ../../usb/host/source/classes/printer; ../../usb/host/source/classes/phdc; ../../usb/host/source/classes/msd/mfs; ../../usb/host/source/classes/msd; ../../usb/host/source/classes/hub; ../../usb/host/source/classes/hid; ../../usb/host/source/classes/cdc; ../../usb/host/source/classes/audio; ../../usb/common/include; ../../mqx/source/tad; ../../mqx/source/psp/cortex_m/cpu; ../../mqx/source/psp/cortex_m/core/M4; ../../mqx/source/psp/cortex_m/compiler/iar; ../../mqx/source/psp/cortex_m; ../../mqx/source/io/usb; ../../mqx/source/io/timer; ../../mqx/source/io/tfs; ../../mqx/source/io/tchres; ../../mqx/source/io/spi; ../../mqx/source/io/serial; ../../mqx/source/io/sdcard/sdcard_spi; ../../mqx/source/io/sdcard/sdcard_esdhc; ../../mqx/source/io/sdcard; ../../mqx/source/io/rtc; ../../mqx/source/io/pipe; ../../mqx/source/io/pcflash; ../../mqx/source/io/pccard; ../../mqx/source/io/pcb/mqxa; ../../mqx/source/io/pcb; ../../mqx/source/io/lwgpio; ../../mqx/source/io/lpm; ../../mqx/source/io/io_null; ../../mqx/source/io/io_mem; ../../mqx/source/io/io_dun; ../../mqx/source/io/i2s/int; ../../mqx/source/io/i2s; ../../mqx/source/io/i2c/polled; ../../mqx/source/io/i2c/int; ../../mqx/source/io/i2c; ../../mqx/source/io/hwtimer; ../../mqx/source/io/hmi/TSS/shared; ../../mqx/source/io/hmi; ../../mqx/source/io/gpio/kgpio; ../../mqx/source/io/gpio; ../../mqx/source/io/flashx/freescale; ../../mqx/source/io/flashx; ../../mqx/source/io/esdhc; ../../mqx/source/io/enet/phy; ../../mqx/source/io/enet/macnet; ../../mqx/source/io/enet; ../../mqx/source/io/dma; ../../mqx/source/io/debug; ../../mqx/source/io/cm; ../../mqx/source/io/can/flexcan; ../../mqx/source/io/adc/kadc; ../../mqx/source/io/adc; ../../mqx/source/include; ../../mqx/source/bsp; ../../config; ../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group USB Class Drivers/audio
    source/classes/audio/: usb_host_audio.c usb_host_audio.h usb_host_audio_intf.c
  group USB Class Drivers/cdc
    source/classes/cdc/: usb_host_cdc.c usb_host_cdc.h usb_host_cdc_intf.c
  group USB Class Drivers/hid
    source/classes/hid/: usb_host_hid.c usb_host_hid.h
  group USB Class Drivers/hub
    source/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group USB Class Drivers/msd
    source/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
    source/classes/msd/mfs/: usbmfs.c usbmfs.h usbmfspr.h
  group USB Class Drivers/phdc
    source/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group USB Class Drivers/printer
    source/classes/printer/: usb_host_printer.c usb_host_printer.h
  group USB Host/include
    source/include/: host_ch9.h host_close.h host_cnfg.h host_cnl.h host_common.h host_dev_list.h host_main.h host_rcv.h host_shut.h host_snd.h hostapi.h
    ../common/include/: usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_misc_prv.h usb_prv.h usb_types.h
  group USB Host/os
    source/rtos/mqx/: mqx_dll.c mqx_dll.h mqx_host.h usb_mqx.c usb_mqx.h
  group USB Host/source
    source/host/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_main.c host_rcv.c host_shut.c host_snd.c
  group USB Low Level Driver/khci
    source/host/khci/: khci.c khci.h
