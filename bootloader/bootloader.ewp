# IAR project bootloader.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512; FTE_BL=1; FTE_EB1=1
  ICCARM.CCIncludePath2: ..\FNET 1.0.0\fnet_demos\common\startup\startup_mk60n512; ..\FNET 1.0.0\fnet_demos\common\startup\startup_mk60n512\common; ..\FNET 1.0.0\fnet_demos\common\startup\startup_mk60n512\drivers; ..\FNET 1.0.0\fnet_demos\common\startup\startup_mk60n512\headers; src\application; ..\FNET 1.0.0\fnet_stack; ..\FNET 1.0.0\fnet_stack\compiler; ..\FNET 1.0.0\fnet_stack\cpu; ..\FNET 1.0.0\fnet_stack\cpu\common; ..\FNET 1.0.0\fnet_stack\cpu\mcf; ..\FNET 1.0.0\fnet_stack\cpu\mk; ..\FNET 1.0.0\fnet_stack\os; ..\FNET 1.0.0\fnet_stack\services; ..\FNET 1.0.0\fnet_stack\services\dhcp; ..\FNET 1.0.0\fnet_stack\services\flash; ..\FNET 1.0.0\fnet_stack\services\fs; ..\FNET 1.0.0\fnet_stack\services\http; ..\FNET 1.0.0\fnet_stack\services\poll; ..\FNET 1.0.0\fnet_stack\services\serial; ..\FNET 1.0.0\fnet_stack\services\shell; ..\FNET 1.0.0\fnet_stack\services\telnet; ..\FNET 1.0.0\fnet_stack\services\tftp; ..\FNET 1.0.0\fnet_stack\stack; ; src\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fte-eb1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config files\bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: ..\FNET 1.0.0\fnet_demos\common\startup\startup_mk60n512; ..\FNET 1.0.0\fnet_demos\common\startup\startup_mk60n512\common; ..\FNET 1.0.0\fnet_demos\common\startup\startup_mk60n512\drivers; ..\FNET 1.0.0\fnet_demos\common\startup\startup_mk60n512\headers; ..\FNET 1.0.0\fnet_demos\common\fnet_application; ..\FNET 1.0.0\fnet_stack; ..\FNET 1.0.0\fnet_stack\compiler; ..\FNET 1.0.0\fnet_stack\cpu; ..\FNET 1.0.0\fnet_stack\cpu\common; ..\FNET 1.0.0\fnet_stack\cpu\mcf; ..\FNET 1.0.0\fnet_stack\cpu\mk; ..\FNET 1.0.0\fnet_stack\os; ..\FNET 1.0.0\fnet_stack\services; ..\FNET 1.0.0\fnet_stack\services\dhcp; ..\FNET 1.0.0\fnet_stack\services\flash; ..\FNET 1.0.0\fnet_stack\services\fs; ..\FNET 1.0.0\fnet_stack\services\http; ..\FNET 1.0.0\fnet_stack\services\poll; ..\FNET 1.0.0\fnet_stack\services\serial; ..\FNET 1.0.0\fnet_stack\services\shell; ..\FNET 1.0.0\fnet_stack\services\telnet; ..\FNET 1.0.0\fnet_stack\services\tftp; ..\FNET 1.0.0\fnet_stack\stack; ; src\
  ICCARM.CCOptLevel: 1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bootloader.srec
  ILINK.IlinkIcfFile: config files\512KB_Pflash.icf
  group (top)
    src/: fapp_model.h fapp_user_config.h fnet_user_config.h main.c
  group applicatoin
    src/application/: fapp.c fapp.h fapp_bench.c fapp_bench.h fapp_config.h fapp_dhcp.c fapp_dhcp.h fapp_diag.c fapp_diag.h fapp_fs.c fapp_fs.h fapp_fs_image.c fapp_fs_image_http09.c fapp_http.c fapp_http.h fapp_image.c fapp_mem.c fapp_mem.h fapp_params.c fapp_params.h fapp_params_prv.h fapp_prv.h fapp_setget.c fapp_setget.h fapp_telnet.c fapp_telnet.h fapp_tftp.c fapp_tftp.h
  group fnet_stack
    ../FNET 1.0.0/fnet_stack/: fnet.h fnet_config.h
  group fnet_stack/compiler
    ../FNET 1.0.0/fnet_stack/compiler/: fnet_comp.h fnet_comp_asm.h fnet_comp_config.h
  group fnet_stack/cpu
    ../FNET 1.0.0/fnet_stack/cpu/: fnet_cpu.h fnet_cpu_config.h
  group fnet_stack/cpu/common
    ../FNET 1.0.0/fnet_stack/cpu/common/: fnet_fec.c fnet_fec.h
  group fnet_stack/cpu/mcf
    ../FNET 1.0.0/fnet_stack/cpu/mcf/: fnet_mcf.c fnet_mcf.h fnet_mcf51cn128_config.h fnet_mcf52235_config.h fnet_mcf52259_config.h fnet_mcf5282_config.h fnet_mcf_cache.c fnet_mcf_checksum.asm fnet_mcf_config.h fnet_mcf_eth.c fnet_mcf_flash.c fnet_mcf_isr.asm fnet_mcf_isr_inst.c fnet_mcf_low.asm fnet_mcf_serial.c fnet_mcf_stdlib.c fnet_mcf_timer.c
  group fnet_stack/cpu/mk
    ../FNET 1.0.0/fnet_stack/cpu/mk/: fnet_mk.c fnet_mk.h fnet_mk60n512_config.h fnet_mk_cache.c fnet_mk_config.h fnet_mk_eth.c fnet_mk_flash.c fnet_mk_isr.c fnet_mk_isr_inst.c fnet_mk_low.asm fnet_mk_serial.c fnet_mk_stdlib.c fnet_mk_timer.c
  group fnet_stack/os
    ../FNET 1.0.0/fnet_stack/os/: fnet_os.h fnet_os_config.h
  group fnet_stack/os/ucosII
    ../FNET 1.0.0/fnet_stack/os/ucosII/: fnet_ucosII_config.h fnet_ucosII_isr.asm
  group fnet_stack/services
    ../FNET 1.0.0/fnet_stack/services/: fnet_services.h fnet_services_config.h shell
  group fnet_stack/services/dhcp
    ../FNET 1.0.0/fnet_stack/services/dhcp/: fnet_dhcp.c fnet_dhcp.h fnet_dhcp_config.h
  group fnet_stack/services/flash
    ../FNET 1.0.0/fnet_stack/services/flash/: fnet_flash.c fnet_flash.h
  group fnet_stack/services/fs
    ../FNET 1.0.0/fnet_stack/services/fs/: fnet_fs.c fnet_fs.h fnet_fs_config.h fnet_fs_prv.h fnet_fs_rom.c fnet_fs_rom.h fnet_fs_root.c fnet_fs_root.h
  group fnet_stack/services/http
    ../FNET 1.0.0/fnet_stack/services/http/: fnet_http.c fnet_http.h fnet_http_auth.c fnet_http_auth.h fnet_http_auth_prv.h fnet_http_cgi.c fnet_http_cgi.h fnet_http_config.h fnet_http_get.c fnet_http_post.c fnet_http_post.h fnet_http_prv.h fnet_http_ssi.c fnet_http_ssi.h fnet_http_ssi_prv.h
  group fnet_stack/services/poll
    ../FNET 1.0.0/fnet_stack/services/poll/: fnet_poll.c fnet_poll.h
  group fnet_stack/services/serial
    ../FNET 1.0.0/fnet_stack/services/serial/: fnet_serial.c fnet_serial.h fnet_serial_config.h
  group fnet_stack/services/shell
    ../FNET 1.0.0/fnet_stack/services/shell/: fnet_shell.c fnet_shell.h fnet_shell_config.h
  group fnet_stack/services/telnet
    ../FNET 1.0.0/fnet_stack/services/telnet/: fnet_telnet.c fnet_telnet.h fnet_telnet_config.h
  group fnet_stack/services/tftp
    ../FNET 1.0.0/fnet_stack/services/tftp/: fnet_tftp.h fnet_tftp_cln.c fnet_tftp_cln.h fnet_tftp_config.h fnet_tftp_srv.c fnet_tftp_srv.h
  group fnet_stack/stack
    ../FNET 1.0.0/fnet_stack/stack/: fnet_arp.c fnet_arp.h fnet_checksum.c fnet_checksum.h fnet_debug.h fnet_error.c fnet_error.h fnet_eth.c fnet_eth.h fnet_eth_prv.h fnet_icmp.c fnet_icmp.h fnet_ip.c fnet_ip_prv.h fnet_isr.c fnet_isr.h fnet_loop.c fnet_loop.h fnet_mempool.c fnet_mempool.h fnet_netbuf.c fnet_netbuf.h fnet_netif.c fnet_netif.h fnet_netif_prv.h fnet_prot.c fnet_prot.h fnet_socket.c fnet_socket.h fnet_socket_prv.h fnet_stack.c fnet_stack.h fnet_stdlib.c fnet_stdlib.h fnet_tcp.c fnet_tcp.h fnet_timer.c fnet_timer.h fnet_timer_prv.h fnet_udp.c fnet_udp.h
    ../../../../fnet_stack/stack/: fnet_ip.h fnet_stack_config.h
  group Linker Files
    config files/: bootloader.icf
  group startup_k60n512
    ../FNET 1.0.0/fnet_demos/common/startup/startup_mk60n512/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h iar.h k60_tower.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group startup_k60n512/common
    ../FNET 1.0.0/fnet_demos/common/startup/startup_mk60n512/common/: alloc.c common.h startup.c startup.h stdlib.c stdlib.h
  group startup_k60n512/drivers
    ../FNET 1.0.0/fnet_demos/common/startup/startup_mk60n512/drivers/: mcg.c mcg.h wdog.c wdog.h
  group startup_k60n512/headers
    ../FNET 1.0.0/fnet_demos/common/startup/startup_mk60n512/headers/: MK60N512VMD100.h MK60X256VMD100.h regfile.h
